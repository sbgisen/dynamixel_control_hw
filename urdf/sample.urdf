Commit message: Expand sample limit

File: urdf/sample.urdf (robot description, URDF)
Before this commit: robot dummy_robot, 4 links, 3 joints
Joints:
- joint arm_joint_1: limit lower=-3.1415 upper=3.1415 effort=100 velocity=10 -> lower=-31.415 upper=31.415 effort=100 velocity=10
